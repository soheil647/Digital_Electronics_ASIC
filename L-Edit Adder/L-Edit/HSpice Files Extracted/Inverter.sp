* Circuit Extracted by Tanner Research's L-Edit Version 8.30 / Extract Version 8.30 ;
* TDB File:  Layout1
* Cell:  Cell0	Version 1.01
* Extract Definition File:  C:\Users\ssa\Desktop\Projects_Github\Digital_Electronics\L-Edit Adder\L-Edit\Tech\MHP_N05.EXT
* Extract Date and Time:  01/02/2020 - 11:58

* Warning:  Layers with Unassigned AREA Capacitance.
*   <allsubs>
*   <LPNP collector>
*   <n well wire>
*   <LPNP emitter>
*   <poly wire>
*   <N Well Resistor>
*   <P Diff Resistor>
*   <subs>
*   <Poly Resistor>
*   <N Diff Resistor>
*   <Metal1>
*   <Metal1-Tight>
*   <Metal2>
*   <Metal2-Tight>
* Warning:  Layers with Unassigned FRINGE Capacitance.
*   <Pad Comment>
*   <AllMetal1>
*   <allsubs>
*   <LPNP collector>
*   <n well wire>
*   <LPNP emitter>
*   <poly wire>
*   <ndiff>
*   <N Well Resistor>
*   <P Diff Resistor>
*   <pdiff>
*   <subs>
*   <Poly Resistor>
*   <N Diff Resistor>
*   <AllMetal2>
*   <Metal3>
*   <Metal1>
*   <Metal1-Tight>
*   <Metal2>
*   <Metal2-Tight>
* Warning:  Layers with Zero Resistance.
*   <Pad Comment>
*   <allsubs>
*   <LPNP collector>
*   <n well wire>
*   <LPNP emitter>
*   <cap using Cap-Well>
*   <poly wire>
*   <subs>
*   <PMOS Capacitor>
*   <NMOS Capacitor>
*   <Metal1>
*   <Metal1-Tight>
*   <Metal2>
*   <Metal2-Tight>

Cpar1 1 0 C=423.83875f
Cpar2 2 0 C=219.47825f
* Warning: Node 3 has zero nodal parasitic capacitance.

M2 ? 3 ? 1 PMOS L=0 W=0
* M2 DRAIN GATE SOURCE BULK (-10 1.5 -7 11)
M1 1 3 2 2 PMOS L=3u W=9.5u AD=137.75p PD=48u AS=133p PS=47u
* M1 DRAIN GATE SOURCE BULK (-10 29.5 -7 39)

* Total Nodes: 3
* Total Elements: 4
* Total Number of Shorted Elements not written to the SPICE file: 0
* Extract Elapsed Time: 0 seconds
.END
